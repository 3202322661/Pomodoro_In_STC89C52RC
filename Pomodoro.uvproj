# Keil uVision project Pomodoro.uvproj, settings and files
target Pomodoro (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Pomodoro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source
    ./: STARTUP.A51
    ./src/: main.c display.c buzzer.c button.c pomodoro.c timer.c sleep.c
  group Include
    ./inc/: config.h display.h buzzer.h button.h pomodoro.h timer.h sleep.h
